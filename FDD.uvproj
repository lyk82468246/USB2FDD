# Keil uVision project FDD.uvproj, settings and files
target FDD (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: FDD +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group AiCube
    ./Sources/: main.c port.c timer.c exti.c usblib.c
    ./Sources/lib/: stc_usb_cdc_32g.lib
